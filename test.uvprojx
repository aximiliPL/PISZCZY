# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM4
  c include: ..\PISZCZY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./: main.c mic.c mic.h dac.c dac.h queue.c queue.h codec.c codec.h
  group inc
    ./: pdm_filter.h queue.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_rcc.h stm32f4xx_spi.h codec.h dac.h mic.h misc.h stm32f4xx.h stm32f4xx_conf.h
  group lib
    ./: libPDMFilter_Keil.lib
  group stdlib
    ./: stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c misc.c
software components: CMSIS:CORE 4.1.0, Device:Startup 2.1.0
